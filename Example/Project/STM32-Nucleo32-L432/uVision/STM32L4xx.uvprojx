# Keil uVision project STM32L4xx.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: COMPILER_KEIL, MCU_STM32L432xC, OSCSRC=HSI, OSCFREQ = 4000
  c misc: -ffunction-sections -fdata-sections -fno-exceptions -Wno-multichar
  c include: .\..\..\..\Src;.\..\..\..\Src\Board\STM32-Nucleo32-L432;{EMBSYSLIB}\Src;{EMBSYSLIB}\Src\Hardware\MCU\STM32L4xx;{EMBSYSLIB}\Src\Hardware\MCU\STM32L4xx\Sys\Keil
  asm define: Stack_Size=0xC00, Heap_Size=0x0C00
  asm misc: --cpreproc
  asm include: {EMBSYSLIB}\Src\Hardware\MCU\STM32L4xx\Sys\Keil
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Source
    ./../../../Src/: main.cpp lib.cpp
  group Header
    ./../../../Src/Board/STM32-Nucleo32-L432/: ReportHandler.h
  group Assembler
    ./: startup.S
  group Doc
    ../../../Src/Board/STM32-Nucleo32-L432/: board_pinout.txt
