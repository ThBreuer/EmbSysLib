# Keil uVision project STM32F4xx.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: COMPILER_KEIL, STM32F407xx, MCU_STM32F407, STM32F407_DISCOVERY, OSCSRC=HSI, OSCFREQ = 8000
  c misc: -ffunction-sections -fdata-sections -fno-exceptions -Wno-pragma-pack
  c include: .\..\..\..\Src;.\..\..\..\Src\Board\STM32F407-Discovery;{EMBSYSLIB}\Src;{EMBSYSLIB}\Src\Hardware\MCU\STM32F4xx;{EMBSYSLIB}\Src\Hardware\MCU\STM32F4xx\Sys\Keil
  asm define: Stack_Size=0x4000, Heap_Size=0x04000
  asm misc: --cpreproc
  asm include: {EMBSYSLIB}\Src\Hardware\MCU\STM32F4xx\Sys\Keil
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./../../../Src/: main.cpp lib.cpp
  group Header
    ./../../../Src/Board/STM32F407-Discovery/: ReportHandler.h
  group Assembler
    ./: startup.S
  group Doc
    ../../../Src/Board/STM32F407-Discovery/: board_pinout.txt
