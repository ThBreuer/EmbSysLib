# Keil uVision project main_STM32F7xx.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2007FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: COMPILER_KEIL, STM32F769xx, MCU_STM32F769x, OSCSRC=HSE, OSCFREQ=25000
  c misc: -ffunction-sections -fdata-sections -fno-exceptions -Wno-pragma-pack
  c include: .\..\..\..\Src;.\..\..\..\Src\Board\STM32F769-Discovery;{EMBSYSLIB}\Src;{EMBSYSLIB}\Src\Hardware\MCU\STM32F7xx;{EMBSYSLIB}\Src\Hardware\MCU\STM32F7xx\Sys\Keil
  asm define: Stack_Size=0x2000, Heap_Size=0x2000
  asm include: {EMBSYSLIB}\Src\Hardware\MCU\STM32F7xx\Sys\Keil
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ../../../Src/: main.cpp lib.cpp
  group Header
    ../../../Src/Board/STM32F769-Discovery/: ReportHandler.h
  group Assembler
    ./: startup.S
  group Doc
    ../../../Src/Board/STM32F769-Discovery/: board_pinout.txt
